# Keil uVision project Lora.uvprojx, settings and files
target sx1276mb1mas (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L073xx, USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER, USE_BAND_868
  c misc: --C99
  c include: ..\..\inc;..\..\..\..\..\..\..\Drivers\BSP\STM32L0xx_Nucleo;..\..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Crypto;..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Mac;..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Phy;..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Utilities;..\..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\..\Middlewares\Third_Party\Lora\Core;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\..\Drivers\BSP\Components\lps25h;..\..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\..\Drivers\BSP\sx1276mb1mas;..\..\..\..\..\..\..\Drivers\BSP\sx1276mb1mas\Phy;..\..\..\..\..\..\..\Drivers\BSP\sx1272mb2das;..\..\..\..\..\..\..\Drivers\BSP\sx1272mb2das\Phy;..\..\..\..\..\..\..\Drivers\BSP\sx1276mb1las;..\..\..\..\..\..\..\Drivers\BSP\sx1276mb1las\Phy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ../../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/hts221/: hts221.c
    ../../../../../../../Drivers/BSP/Components/lps25h/: lps25h.c
    ../../../../../../../Drivers/BSP/Components/lps25hb/: lps25hb.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_hum_temp.c x_nucleo_iks01a1_pressure.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Drivers/BSP/sx1272mb2das
    ../../../../../../../Drivers/BSP/sx1272mb2das/: sx1272mb2das.c
    ../../../../../../../Drivers/BSP/sx1272mb2das/Phy/: sx1272.c
  group Drivers/BSP/sx1276mb1mas
    ../../../../../../../Drivers/BSP/sx1276mb1mas/: sx1276mb1mas.c
    ../../../../../../../Drivers/BSP/sx1276mb1mas/Phy/: sx1276.c
  group Drivers/BSP/sx1276mb1las
    ../../../../../../../Drivers/BSP/sx1276mb1las/: sx1276mb1las.c
    ../../../../../../../Drivers/BSP/sx1276mb1las/Phy/: sx1276.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c
  group Projects/MDK-ARM
    ./: startup_stm32l073xx.s
  group Projects/classA
    ../../src/: bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c stm32l0xx_hal_msp.c stm32l0xx_hw.c stm32l0xx_it.c vcom.c
  group Middlewares/Lora/Core
    ../../../../../../../Middlewares/Third_Party/Lora/Core/: lora.c
  group Middlewares/Lora/Mac
    ../../../../../../../Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
  group Middlewares/Lora/Utilities
    ../../../../../../../Middlewares/Third_Party/Lora/Utilities/: delay.c low_power.c timeServer.c utilities.c
  group Middlewares/Lora/Crypto
    ../../../../../../../Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
target sx1272mb2das (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: as above
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target sx1276mb1las (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: as above
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
